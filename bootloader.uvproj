# Keil uVision project bootloader.uvproj, settings and files
target MKL25Z (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: bootloader
  c flags: Optim=1
  c include: .;..\ff9b\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group support
    ./: startup_MKL25Z4.s system_MKL25Z4.c spi.c
    ../ff9b/port/: mmc-mkl25z.c
    ../ff9b/src/: ff.c
  group bootloader
    ./: main.c
